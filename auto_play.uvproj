# Keil uVision project auto_play.uvproj, settings and files
target Target 1 (MCS-51)
  device: 87C51 Intel
  cpu: IRAM(0-0x7F)  IROM(0-0xFFF) CLOCK(12000000)
  output: auto_play +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c timer0.c beep.c new_autoplay.c
